# Keil uVision project Cellphone.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Cellphone
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: -Ospace
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Main
    ./: main.c interrupts.c tinyfont.c display.c
  group Clock
    ./clock/: clock.c displayClock.c incHours.c incMinutes.c incSeconds.c
  group Timer
    ./timer/: displayTimer.c incTimer.c incTimerMinutes.c incTimerSeconds.c timer.c
  group Hardware
    ./hardware/: I2C.c JOY.c Serial.c
  group SMS
    ./sms/: sms.c sms_threads.c
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS2:Keil RTX5 5.1.0, Board Support:Buttons 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, CMSIS Driver:I2C 2.7, Device:STM32Cube Framework:Classic 1.1.1, Device:STM32Cube HAL:ADC 1.1.1, Device:STM32Cube HAL:Common 1.1.1, Device:STM32Cube HAL:Cortex 1.1.1, Device:STM32Cube HAL:DCMI 1.1.1, Device:STM32Cube HAL:DMA 1.1.1, Device:STM32Cube HAL:GPIO 1.1.1, Device:STM32Cube HAL:I2C 1.1.1, Device:STM32Cube HAL:RCC 1.1.1, Device:STM32Cube HAL:SRAM 1.1.1, Device:STM32Cube HAL:USART 1.1.1, Device:Startup 2.1.1
